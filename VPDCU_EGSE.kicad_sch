File: VPDCU_EGSE.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: First Draft of the Schematic
Other:
- removed sheet Power - Sequencing
