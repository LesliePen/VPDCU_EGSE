File: Block Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: PCB Checked version
Other:
- note removed: "+??V"
- note removed: "+A3V3"
